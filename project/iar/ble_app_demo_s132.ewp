# IAR project ble_app_demo_s132.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: nrf52832_xxaa NordicSemi nRF52832_xxAA
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CONFIG_GPIO_AS_PINRESET; FLOAT_ABI_HARD; NRF52; NRF52832_XXAA; NRF52_PAN_74; NRF_SD_BLE_API_VERSION=6; S132; SOFTDEVICE_PRESENT; SWI_DISABLE0
  ICCARM.CCIncludePath2: ..\..\modules\nrfx\mdk; ..\..\components\softdevice\s132\headers; ..\..\components\toolchain\cmsis\include; ..\..\components\libraries\log; ..\..\components\libraries\experimental_section_vars; ..\..\components\libraries\strerror; ..\..\components\libraries\atomic; ..\..\components\libraries\atomic_fifo; ..\..\components\libraries\atomic_flags; ..\..\components\libraries\balloc; ..\..\components\libraries\crc16; ..\..\components\libraries\fstorage; ..\..\components\libraries\hardfault\nrf52; ..\..\components\libraries\ringbuf; ..\config; ..\..\modules\nrfx\mdk; ..\..\components\softdevice\common; ..\..\components\libraries\log; ..\..\components\libraries\log\src; ..\..\components\libraries\util; ..\..\integration\nrfx; ..\..\components\libraries\memobj; ..\..\components\libraries\mem_manager; ..\..\components\libraries\pwr_mgmt; ..\..\components\ble\ble_advertising; ..\..\components\ble\ble_db_discovery; ..\..\components\ble\peer_manager; ..\..\modules\nrfx; ..\..\external\fprintf; ..\..\components\ble\common; ..\..\components\libraries\uart; ..\..\components\libraries\timer; ..\..\components\libraries\fds; ..\..\modules\nrfx\drivers\include; ..\..\components\libraries\mutex; ..\..\components\libraries\delay; ..\..\components\libraries\gpiote; ..\..\modules\nrfx\hal; ..\..\integration\nrfx\legacy; ..\..\external\segger_rtt; ..\..\components\ble\nrf_ble_gatt; ..\..\components\ble\nrf_ble_qwr; ..\..\components\libraries\hardfault; ..\..\components\libraries\sensorsim; ..\..\app; ..; ..\..\components\ble\ble_services\ble_hrs; ..\..\components\ble\ble_services\ble_dis; ..\..\m_libraries
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ble_app_demo_s132.hex
  ILINK.IlinkOutputFile: ble_app_demo_s132.out
  ILINK.IlinkIcfFile: E:\nRF5_SDK_15.2.0_9412b96\nRF32_Demo\project\iar\ble_app_demo_s132_iar_nRF5x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../../app/: advertising.c flasg_data_storage.c flash_storage.c service.c
    ../: main.c
    ../config/: sdk_config.h
  group CMSIS
    ../../modules/nrfx/mdk/: iar_startup_nrf52.s system_nrf52.c
  group m_Libraries
    ../../m_libraries/: my_queue.c
  group nRF_BLE
    ../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_uart.c nrfx_uarte.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c app_error_handler_iar.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/timer/: app_timer.c
    ../../components/libraries/fds/: fds.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_nvmc.c nrf_fstorage_sd.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../modules/nrfx/hal/: nrf_nvmc.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/libraries/sensorsim/: sensorsim.c
  group nRF_log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
  group nRF_Service
    ../../components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c
  group UTF8
    ../../external/utf_converter/: utf.c
