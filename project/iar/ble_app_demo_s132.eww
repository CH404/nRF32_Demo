<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\ble_app_demo_s132.ewp</path>
    </project>
    <batchBuild />
</workspace>
