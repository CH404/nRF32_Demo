# Keil uVision project ble_app_demo_s132.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ble_app_demo_s132 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_GPIO_AS_PINRESET NRF52 NRF52832_XXAA NRF_SD_BLE_API_VERSION=6 SOFTDEVICE_PRESENT SWI_DISABLE0 __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --c99 --reduce_paths
  c include: ..\..\components\libraries\atomic;..\..\components\libraries\atomic_fifo;..\..\components\libraries\atomic_flags;..\..\components\libraries\balloc;..\..\components\libraries\button;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\fstorage;..\..\components\libraries\memobj;..\..\components\libraries\crc16;..\..\components\libraries\fds;..\..\components\libraries\hardfault;..\..\components\libraries\pwr_mgmt;..\..\components\libraries\ringbuf;..\..\external\fprintf;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\log;..\..\external\segger_rtt;..\..\components\softdevice\common;..\..\integration\nrfx\legacy;..\..\modules\nrfx\drivers\include;..\..\modules\nrfx\drivers\src\prs;..\..\external\utf_converter;..\..\components\ble\common;..\..\components\ble\nrf_ble_gatt;..\..\components\ble\ble_advertising;..\..\components\ble\nrf_ble_qwr;..\..\components\ble\peer_manager;..\..\project;..\..\modules\nrfx;..\..\integration\nrfx;..\config;..\..\modules\nrfx\mdk;..\..\components\softdevice\s132\headers;..\..\components\libraries\log\src;..\..\components\libraries\mutex;..\..\components\libraries\timer;..\..\modules\nrfx\hal;..\..\components\libraries\delay;..\..\app
  library: MicroLIB
  memory RVCT4: ROM 0x26000 size 0x5a000
  memory RVCT9: RAM 0x20002218 size 0xdde8
  link misc: --diag_suppress 6330
  group CMSIS
    ../../modules/nrfx/mdk/: arm_startup_nrf52.s system_nrf52.c
  group Application
    ../: main.c
    ../config/: sdk_config.h
    ../../app/: advertising.c
  group nRF_Drivers
    ../../integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_uart.c
    ../../modules/nrfx/drivers/src/: nrfx_clock.c nrfx_gpiote.c nrfx_power_clock.c nrfx_uart.c nrfx_uarte.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../: global.c
  group nRF_Libraries
    ../../components/libraries/button/: app_button.c
    ../../components/libraries/scheduler/: app_scheduler.c
    ../../components/libraries/timer/: app_timer.c
    ../../components/libraries/fds/: fds.c
    ../../components/libraries/hardfault/: hardfault_implementation.c
    ../../components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../components/libraries/atomic_flags/: nrf_atflags.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../components/ble/ble_services/ble_hrs/: ble_hrs.c
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_str_formatter.c nrf_log_frontend.c nrf_log_default_backends.c nrf_log_backend_uart.c nrf_log_backend_serial.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../components/softdevice/common/: nrf_sdh_soc.c nrf_sdh_ble.c nrf_sdh.c
  group nRF_BLE
    ../../components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../components/ble/ble_advertising/: ble_advertising.c
    ../../components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../components/ble/peer_manager/: auth_status_tracker.c gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c peer_manager_handler.c pm_buffer.c security_dispatcher.c security_manager.c
  group UTF8
    ../../external/utf_converter/: utf.c
